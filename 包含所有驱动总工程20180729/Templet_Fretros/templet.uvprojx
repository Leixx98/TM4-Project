# Keil uVision project templet.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templet +hex
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: PART_TM4C1294NCPDT
  c include: ..\Templet_Fretros;.\Freetros\include;.\Freetros\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group User
    ./user/: startup_rvmdk.S blinky.c
  group Driverlib
    ./driverlib/rvmdk/: driverlib.lib
  group Utils
    ./utils/: uartstdio.c buttons.c
  group Freetros
    ./Freetros/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Freetros_Portable
    ./Freetros/portable/MemMang/: heap_4.c
    ./Freetros/portable/RVDS/ARM_CM4F/: port.c
  group Functions
    ./functions/: led_task.c uartprint.c tim.c key.c ads1256.c delay.c ad9959.c ads1115.c dac5618.c dac8811.c ads11152.c dac56182.c dac8501.c fpga.c fpgadrawline.c uartreceive.c sort.c
